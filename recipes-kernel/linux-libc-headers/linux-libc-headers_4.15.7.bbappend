FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://install-linux-ashmem.h.patch"
